# Keil uVision project IF_CurrentLoop.uvprojx, settings and files
target IF_CurrentLoop (5060960::V5.06 update 7 (build 960)::.\ARMCLANG5)
  device: LCM32F039 LCMicroelectronics
  pack: Keil.LCM32F0xx_DFP.0.4.70
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: IF_CurrentLoop +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Device\Include;..\Driver\inc;..\Source\inc;..\Function\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup
    ../Device/Source/ARM/: lcm32f039_startup.s
  group Main
    ../Source/src/: main.c
  group Board and Interrupts
    ../Source/src/: DMA_Interrupt.c User_Interrupt.c User_PeripheralInit.c ADC_Init.c GPIO_Init.c OPA_Init.c Timer_Init.c
  group LCM32F039 Drivers
    ../Driver/src/: lcm32f039_adc.c lcm32f039_acmp.c lcm32f039_dac.c lcm32f039_div.c lcm32f039_dma.c lcm32f039_gpio.c lcm32f039_opa.c lcm32f039_rcc.c lcm32f039_tim.c lcm32f039_flash.c lcm32f039_pwr.c
  group I-F Current Loop
    ../Function/src/: function.c Math.c SysProtection.c IfControl.c CurrentLoop.c PI_Regulator.c SVPWM.c ADC_Calc.c
