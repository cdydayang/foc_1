# Keil uVision project demo.uvprojx, settings and files
target demo (5060960::V5.06 update 7 (build 960)::.\ARMCLANG5)
  device: LCM32F039 LCMicroelectronics
  pack: Keil.LCM32F0xx_DFP.0.4.70
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: uart +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\Device\Include;..\..\Driver\inc;..\..\Source\inc;..\..\MotorLib\inc;..\..\Function\inc;..\..\PumpComm\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group ReadMe
    ./: ReadME.txt
  group Startup
    ../../Device/Source/ARM/: lcm32f039_startup.s
  group Main
    ../../Source/src/: main.c
  group usr
    ../../Source/src/: DMA_Interrupt.c User_Interrupt.c User_PeripheralInit.c ADC_Init.c GPIO_Init.c OPA_Init.c Timer_Init.c
  group Driver
    ../../Driver/src/: lcm32f039_adc.c lcm32f039_acmp.c lcm32f039_dac.c lcm32f039_dbgmcu.c lcm32f039_div.c lcm32f039_dma.c lcm32f039_eeprom.c lcm32f039_exti.c lcm32f039_flash.c lcm32f039_gpio.c lcm32f039_i2c.c lcm32f039_I2cEmulation.c lcm32f039_iwdg.c lcm32f039_lcd.c lcm32f039_opa.c lcm32f039_pwr.c lcm32f039_rcc.c lcm32f039_ssp.c lcm32f039_tim.c lcm32f039_uart.c lcm32f039_wt.c
  group function
    ../../Function/src/: Math.c function.c SysProtection.c IfControl.c CurrentLoop.c PI_Regulator.c SpeedLoop.c SVPWM.c ADC_Calc.c
  group FOC_LIB
    ../../MotorLib/src/: Estimation.c
  group Comm
    ../../PumpComm/src/: Pump_Comm.c Pump_Function.c
